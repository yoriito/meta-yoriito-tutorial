# Configure polling rate for USB mice
CMDLINE_MOUSEPOLL = "usbhid.mousepoll=0"

CMDLINE += " ${CMDLINE_MOUSEPOLL}"
